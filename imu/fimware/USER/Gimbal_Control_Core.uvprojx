# Keil uVision project Gimbal_Control_Core.uvprojx, settings and files
target SOLDER_GIMBAL (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Gimbal_Control_Core
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,__TARGET_FPU_VFP,__FPU_PRESENT=1
  c include: ..\File\API;..\File\APP;..\File\BSP;..\File\STM32_LIB\CORE;..\File\STM32_LIB\inc;..\File\USER;..\USER
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ../File/USER/: global_declare.c global_declare.h os.c os.h main.c main.h stm32f4xx_it.c stm32f4xx_it.h time_estimate.c time_estimate.h gimbal_control_types.h
    ../File/BSP/: bsp_init.c bsp_init.h
  group TASK
    ../File/APP/: systemmonitor_task.c systemmonitor_task.h imu_update.c imu_update.h temp_control.c temp_control.h gimbal_task.c gimbal_task.h distance_measure_task.c distance_measure_task.h
  group API
    ../File/API/: rm_algorithm.c rm_algorithm.h dji_protocol.c dji_protocol.h usart_protocol.c usart_protocol.h general_math.c general_math.h verify.c verify.h bmi088_driver.c bmi088_driver.h
  group BSP
    ../File/BSP/: systick.c systick.h delay.c delay.h led.c led.h can.c can.h usart.c usart.h spi.c spi.h time.c time.h wwdg.c wwdg.h flash.c flash.h steering_engine.c steering_engine.h
  group STM32_LIB
    ../File/STM32_LIB/src/: misc.c stm32f4xx_can.c stm32f4xx_dma.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group CORE
    ../File/STM32_LIB/CORE/: startup_stm32f4xx.s system_stm32f4xx.c system_stm32f4xx.h
software components: CMSIS:CORE 5.1.1, CMSIS:DSP 1.5.2, Device:Startup 2.6.2
